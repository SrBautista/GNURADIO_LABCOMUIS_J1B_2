options:
  parameters:
    author: CarlosBautista2171513
    copyright: UIS
    generate_options: qt_gui
    id: MultriplexacionPAM
    output_language: python
    title: MultriplexaPAM
  states: {}

blocks:
- name: D
  id: variable_qtgui_range
  parameters:
    label: Anchodepulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: delay1
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: delay2
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: delay3
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: am
  id: variable_qtgui_range
  parameters:
    label: amplitudmensaje
    start: '0'
    step: '10e-3'
    stop: '10'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuenciamensaje
    start: '0'
    step: '10'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuenciadepulsos
    start: '0'
    step: '1'
    stop: 10e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: ModuladorPAM_3
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_3_0
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_3_1
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_3_2
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3_0
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_3_1
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_3_2
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModuladorPAM_3, '0', blocks_add_xx_0, '0']
- [ModuladorPAM_3, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_3_0, '0', blocks_delay_2, '0']
- [ModuladorPAM_3_1, '0', blocks_delay_0, '0']
- [ModuladorPAM_3_2, '0', blocks_delay_1, '0']
- [analog_sig_source_x_3, '0', ModuladorPAM_3, '0']
- [analog_sig_source_x_3_0, '0', ModuladorPAM_3_1, '0']
- [analog_sig_source_x_3_1, '0', ModuladorPAM_3_0, '0']
- [analog_sig_source_x_3_2, '0', ModuladorPAM_3_2, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0, '0', blocks_add_xx_0, '3']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_2, '0', blocks_add_xx_0, '1']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
