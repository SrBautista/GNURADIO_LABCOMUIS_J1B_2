options:
  parameters:
    author: CarlosBautista2171513
    copyright: UIS
    generate_options: qt_gui
    id: ModuladorAM
    output_language: python
    title: Modulador de Amplitud
  states: {}

blocks:
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganacia del trasmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coef Sensibilidad
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: b
  id: variable_qtgui_range
  parameters:
    label: b
    start: '-1'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia Mensaje
    start: '300'
    step: '100'
    stop: 21e3
    value: 1e3
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: A1
    start: '-1/Ka'
    step: '1e-3'
    stop: 1/Ka
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/64
  states: {}
- name: CalculoPotenciaComunicaciones_0_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: SSB_0
  id: SSB
  parameters:
    Ac: ac
    B: b
    K: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: offset
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [SSB_0, '0', blocks_throttle_0, '0']
- [SSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicaciones_0_0, '0']
- [analog_sig_source_x_0, '0', SSB_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
