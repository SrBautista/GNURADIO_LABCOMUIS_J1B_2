options:
  parameters:
    author: CarlosBautista2171513
    category: '[modulos_J1B_G2]'
    copyright: UIS
    generate_options: hb_qt_gui
    id: CalculoPotenciaComunicaciones
    output_language: python
    title: CalculoPotenciaComunicaciones
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ModulosEfren_SumaVector_0
  id: ModulosEfren_SumaVector
  parameters:
    Param1: l_vect
  states: {}
- name: PotenciaLineal_W
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: PotenciaLineal_W
    type: float
  states: {}
- name: PotenciaLogaritmica_dbm
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: PotenciaLogaritmica_dbm
    type: float
  states: {}
- name: Potencialogaritmica_dbW
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencialogaritmica_dbW
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: l_vect
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3.70053e-6'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '30'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: l_vect
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: l_vect
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: l_vect
  id: parameter
  parameters:
    label: Longitud FFT
    type: intx
    value: '1024'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [ModulosEfren_SumaVector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', ModulosEfren_SumaVector_0, '0']
- [blocks_multiply_const_vxx_0, '0', PotenciaLineal_W, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_nlog10_ff_0, '0', Potencialogaritmica_dbW, '0']
- [blocks_nlog10_ff_1, '0', PotenciaLogaritmica_dbm, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
